Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Capri-Sofa 3 seater - ver4.ifc
Time: 2024-12-10T14:52:42
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Capri-Sofa 3 seater_0 - ObjectType: SketchupGroup
 | Capri-Sofa 3 seater_1 - ObjectType: SketchupGroup
 | Capri-Sofa 3 seater_2 - ObjectType: SketchupGroup
 | Capri-Sofa 3 seater_3 - ObjectType: SketchupGroup
